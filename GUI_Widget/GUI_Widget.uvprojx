# Keil uVision project GUI_Widget.uvprojx, settings and files
target Target 1 (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: GUI_Widget
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 5.3.0, CMSIS:DSP 1.7.0, CMSIS:RTOS2:Keil RTX5 5.5.1, Board Support:Drivers:Basic I/O 1.1.1, Board Support:Drivers:SDRAM 1.1.1, Board Support:Drivers:Touch Screen 1.1.1, Board Support:Touchscreen 1.1.1, Board Support:emWin LCD 1.1.1, Device:STM32Cube Framework:Classic 1.2.7, Device:STM32Cube HAL:Common 1.2.7, Device:STM32Cube HAL:Cortex 1.2.7, Device:STM32Cube HAL:DMA 1.2.7, Device:STM32Cube HAL:DMA2D 1.2.7, Device:STM32Cube HAL:GPIO 1.2.7, Device:STM32Cube HAL:I2C 1.2.7, Device:STM32Cube HAL:LTDC 1.2.7, Device:STM32Cube HAL:PWR 1.2.7, Device:STM32Cube HAL:RCC 1.2.7, Device:STM32Cube HAL:RNG 1.2.7, Device:STM32Cube HAL:SDRAM 1.2.7, Device:STM32Cube HAL:TIM 1.2.7, Device:STM32Cube HAL:UART 1.2.7, Device:Startup 1.2.4, Graphics Display:STM32F746G-Discovery 1.0.2, Graphics:CORE 5.50.0, Graphics:Input Device:Touchscreen 5.50.0
